<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>plot_sink</key>
<param><key>id</key><value>plot_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>step_offset</key>
<param><key>id</key><value>step_offset_0</value></param>
<param><key>type</key><value>f32_f32</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>S</key><value>1</value></param>
<param><key>H_Off</key><value>0</value></param>
<param><key>W_Off</key><value>0</value></param>
</block>
<block>
<key>multiorder_tf</key>
<param><key>id</key><value>multiorder_tf_0</value></param>
<param><key>type</key><value>f32_f32</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>P</key><value>0</value></param>
<param><key>I</key><value>0</value></param>
<param><key>D</key><value>0</value></param>
<param><key>n0</key><value>5</value></param>
<param><key>n1</key><value>0</value></param>
<param><key>n2</key><value>0</value></param>
<param><key>n3</key><value>0</value></param>
<param><key>d0</key><value>1</value></param>
<param><key>d1</key><value>1</value></param>
<param><key>d2</key><value>5</value></param>
<param><key>d3</key><value>0</value></param>
<param><key>window</key><value>1</value></param>
</block>
<connection><source_block_id>multiorder_tf_0</source_block_id><sink_block_id>plot_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>step_offset_0</source_block_id><sink_block_id>multiorder_tf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
