<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>/home/mushirahmed/demo1.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Number Plot</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>100000</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
