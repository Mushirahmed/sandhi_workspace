<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gr_null_source</key>
<param><key>id</key><value>gr_null_source_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>plot_sink</key>
<param><key>id</key><value>plot_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>gsz</key><value>50</value></param>
<param><key>zoom</key><value>1</value></param>
</block>
<block>
<key>scifile_generic</key>
<param><key>id</key><value>scifile_generic_0</value></param>
<param><key>type</key><value>f32_f32</value></param>
<param><key>path</key><value>/home/mushirahmed/scilab_workspace/transeint_second_order.sci</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>window</key><value>1</value></param>
</block>
<connection><source_block_id>gr_null_source_0</source_block_id><sink_block_id>scifile_generic_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>scifile_generic_0</source_block_id><sink_block_id>plot_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
