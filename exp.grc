<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>exp_expo</key>
<param><key>id</key><value>exp_expo_1</value></param>
<param><key>g</key><value>12</value></param>
<param><key>a</key><value>3</value></param>
<param><key>b</key><value>2</value></param>
<param><key>w</key><value>1</value></param>
</block>
<block>
<key>plot_sink</key>
<param><key>id</key><value>plot_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>gsz</key><value>50</value></param>
<param><key>zoom</key><value>1</value></param>
</block>
<block>
<key>step_offset</key>
<param><key>id</key><value>step_offset_0</value></param>
<param><key>type</key><value>f32_f32</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>S</key><value>1</value></param>
<param><key>H_Off</key><value>1</value></param>
<param><key>W_Off</key><value>0</value></param>
</block>
<connection><source_block_id>exp_expo_1</source_block_id><sink_block_id>plot_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>step_offset_0</source_block_id><sink_block_id>exp_expo_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
