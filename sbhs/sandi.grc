<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>variable_slider_0</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>30</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>40</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>gr.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>amp</key><value>30</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>plot_sink</key>
<param><key>id</key><value>plot_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>gsz</key><value>1000</value></param>
<param><key>zoom</key><value>0</value></param>
</block>
<block>
<key>sbfan</key>
<param><key>id</key><value>sbfan_0</value></param>
<param><key>type</key><value>f32_f32</value></param>
<param><key>fan_val</key><value>0</value></param>
<param><key>heat_val</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>window</key><value>1</value></param>
</block>
<block>
<key>gr_add_const_vxx</key>
<param><key>id</key><value>gr_add_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>30</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_delay</key>
<param><key>id</key><value>gr_delay_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>5</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>const_source_x_0</source_block_id><sink_block_id>sbfan_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0</source_block_id><sink_block_id>gr_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sbfan_0</source_block_id><sink_block_id>plot_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_const_vxx_0</source_block_id><sink_block_id>gr_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_delay_0</source_block_id><sink_block_id>sbfan_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
