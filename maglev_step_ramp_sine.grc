<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gr_null_source</key>
<param><key>id</key><value>gr_null_source_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_4</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Zeta</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>notebook</key><value>notebook_0,1</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_5</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>OmegaD</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>notebook</key><value>notebook_0,1</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Tr</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>notebook</key><value>notebook_0,2</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Pv</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>notebook</key><value>notebook_0,3</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>notebook_0</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['Response Plot', 'Parameters Values','Parameters Values','Parameters Values']</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_9</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Td</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>notebook</key><value>notebook_0,3</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>OmegaN</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>notebook</key><value>notebook_0,1</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_7</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Tp</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>notebook</key><value>notebook_0,2</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_10</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Ts</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>notebook</key><value>notebook_0,2</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Qs</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>notebook</key><value>notebook_0,3</value></param>
</block>
<block>
<key>plot_sink</key>
<param><key>id</key><value>plot_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>gsz</key><value>700</value></param>
<param><key>zoom</key><value>0</value></param>
<param><key>notebook</key><value>notebook_0,0</value></param>
</block>
<block>
<key>step_step</key>
<param><key>id</key><value>step_step_0</value></param>
<param><key>type</key><value>fc32_fc32</value></param>
<param><key>num_outputs</key><value>10</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>itype</key><value>12</value></param>
<param><key>n0</key><value>0.00137438</value></param>
<param><key>n1</key><value>0</value></param>
<param><key>n2</key><value>0</value></param>
<param><key>n3</key><value>0</value></param>
<param><key>d0</key><value>4.78533</value></param>
<param><key>d1</key><value>3.30579</value></param>
<param><key>d2</key><value>1</value></param>
<param><key>d3</key><value>0</value></param>
<param><key>window</key><value>10</value></param>
</block>
<connection><source_block_id>gr_null_source_0</source_block_id><sink_block_id>step_step_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>step_step_0</source_block_id><sink_block_id>plot_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>step_step_0</source_block_id><sink_block_id>wxgui_numbersink2_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>step_step_0</source_block_id><sink_block_id>wxgui_numbersink2_4</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>step_step_0</source_block_id><sink_block_id>wxgui_numbersink2_10</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>step_step_0</source_block_id><sink_block_id>wxgui_numbersink2_5</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>step_step_0</source_block_id><sink_block_id>wxgui_numbersink2_3</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>step_step_0</source_block_id><sink_block_id>wxgui_numbersink2_2</sink_block_id><source_key>8</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>step_step_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>9</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>step_step_0</source_block_id><sink_block_id>wxgui_numbersink2_9</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>step_step_0</source_block_id><sink_block_id>wxgui_numbersink2_7</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
</flow_graph>
